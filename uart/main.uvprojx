# Keil uVision project main.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32F072RBTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: main +hex
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=1
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Source Group 1
    ./: main.c uart_init.h uart_init.c main.h pwm_init.c pwm_init.h handlers.c global_params.h
software components: CMSIS:CORE 5.5.0, Device:Startup 1.0.0
